## omi/firmware/test/Kconfig
```kconfig
source "Kconfig.zephyr"

config PCBA_TEST
	bool "Enable PCBA test mode"
	default n
```
